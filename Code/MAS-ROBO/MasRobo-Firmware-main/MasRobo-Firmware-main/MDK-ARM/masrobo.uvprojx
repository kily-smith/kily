# Keil uVision project masrobo.uvprojx, settings and files
target STM32F407_RMC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: masrobo
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\bsp\cubemx\rm_c\Core\Inc;..\bsp\cubemx\rm_c\Drivers\CMSIS\Include;..\bsp\cubemx\rm_c\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\bsp\cubemx\rm_c\Drivers\STM32F4xx_HAL_Driver\Inc;..\bsp\cubemx\rm_c\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\bsp\cubemx\rm_c\Middlewares\Third_Party\FreeRTOS\Source\include;..\bsp\cubemx\rm_c\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\app;..\app\chassis;..\app\gimbal;..\bsp\cubemx\rm_c\USB_DEVICE\App;..\bsp\cubemx\rm_c\USB_DEVICE\Target;..\bsp\cubemx\rm_c\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\bsp\cubemx\rm_c\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\modules;..\modules\log;..\bsp\boards;..\modules\support;..\modules\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group stm32f4xx_hal
    ../bsp/cubemx/rm_c/MDK-ARM/: startup_stm32f407xx.s
    ../bsp/cubemx/rm_c/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_ll_usb.c
  group freertos
    ../bsp/cubemx/rm_c/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../bsp/cubemx/rm_c/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../bsp/cubemx/rm_c/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../bsp/cubemx/rm_c/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group cubemx
    ../bsp/cubemx/rm_c/Core/Src/: main.c freertos.c can.c dma.c gpio.c i2c.c rng.c spi.c usart.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c stm32f4xx_hal_msp.c
    ../bsp/cubemx/rm_c/USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ../bsp/cubemx/rm_c/USB_DEVICE/Target/: usbd_conf.c
    ../bsp/cubemx/rm_c/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../bsp/cubemx/rm_c/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group boards
    ../bsp/boards/: board.c drv_uart.c
  group app
    ../app/: init.c
  group modules
    ../modules/log/: log.c
  group support
    ../modules/support/: fifo.c
